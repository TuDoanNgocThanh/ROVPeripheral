# Keil uVision project STM32F103.uvprojx, settings and files
target STM32F1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,HSE_VALUE = 8000000
  c include: ..\F1;.\CMSIS;.\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c current.c gripper.c peripheral.c relay.c variable.c leak.c
  group STM32F1
    ./STM32F10x_StdPeriph_Driver/src/: stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_usart.c misc.c stm32f10x_rcc.c stm32f10x_adc.c
  group MDK-ARM
    ./RTE/Device/STM32F103C8/: startup_stm32f10x_md.s
  group CMSIS
    ./CMSIS/: core_cm3.c stm32f10x.h stm32f10x_it.c
    ./RTE/Device/STM32F103C8/: system_stm32f10x.c
software components: CMSIS:CORE 5.4.0
